# Keil uVision project project.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: MM32F5333D7PV MindMotion
  pack: MindMotion.MM32F5330_DFP.0.0.2
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Star-MC1") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf --bin --output .\Objects\project.bin .\Objects\project.axf
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: APP_TINYUSB CFG_TUSB_MCU BRD_MINI_F5330 DCACHE_DISABLED ICACHE_DISABLED
  c include: ..\device;..\board;..;..\device\CMSIS\Include;..\application;..\components\tinyusb\src;..\device\drivers
  asm include: ..
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\device\mdk\linker\mm32f5333d_flash.scf
  group application
    ../application/: main.c tud_usb_descriptors.c tusb_config.h can.c can.h error.c error.h slcan.c slcan.h led.c led.h
  group board
    ../board/: board_init.c board_init.h clock_init.c clock_init.h pin_init.c pin_init.h tud_dcd_port.c
  group drivers
    ../device/drivers/: hal_adc.c hal_adc.h hal_bkp.c hal_bkp.h hal_common.h hal_comp.c hal_comp.h hal_cordic.c hal_cordic.h hal_crc.c hal_crc.h hal_dac.c hal_dac.h hal_dma.c hal_dma.h hal_dma_request.h hal_exti.c hal_exti.h hal_flash.c hal_flash.h hal_flexcan.c hal_flexcan.h hal_gpio.c hal_gpio.h hal_i2c.c hal_i2c.h hal_i2s.c hal_i2s.h hal_i3c.c hal_i3c.h hal_iwdg.c hal_iwdg.h hal_lptim.c hal_lptim.h hal_lpuart.c hal_lpuart.h hal_mds.c hal_mds.h hal_mds_remap.h hal_rcc.c hal_rcc.h hal_rtc.c hal_rtc.h hal_spi.c hal_spi.h hal_syscfg.c hal_syscfg.h hal_tim.c hal_tim.h hal_uart.c hal_uart.h hal_usart.c hal_usart.h hal_usb.c hal_usb.h hal_usb_bdt.h hal_wwdg.c hal_wwdg.h
  group device
    ../device/: hal_device_registers.h mm32f5333d.h mm32f5333d_features.h system_mm32f5333d.c system_mm32f5333d.h
    ../device/mdk/: startup_mm32f5333d.S
  group tinyusb
    ../components/tinyusb/src/common/: tusb_fifo.c
    ../components/tinyusb/src/device/: usbd.c usbd_control.c
    ../components/tinyusb/src/: tusb.c
    ../components/tinyusb/src/class/cdc/: cdc_device.c
